temp_scale
.options temp=0.1k
.end
